# Keil uVision project CortexM7.uvprojx, settings and files
target Debug (6160000::V6.16::ARMCLANG)
  device: STM32H755ZITx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x38000000,0x00010000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) XRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: CortexM7
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: DEBUG,USE_FULL_ASSERT,STM32H755xx,CORE_CM7
  c include: .\APP;..\Common;..\Common\BSP;..\Common\SYS;.\GNU\cminpack-1.3.8;.\GMT;.\GMT\resource;.\GMT\resource\header
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group APP
    ./APP/: main.h main.c task.h task.c test.h test.c idle.h idle.c
  group BSP
    ../Common/BSP/: BSP_STM32H7.h BSP_STM32H7.c MSP_STM32H7.h MSP_STM32H7.c IRQ_STM32H7.h IRQ_STM32H7.c LED_STM32H7.h LED_STM32H7.c SPI_STM32H7.h SPI_STM32H7.c TMC_STM32H7.h TMC_STM32H7.c
  group GMT
    ./GMT/: stewart_test.cpp
    ./GMT/resource/cpp/: MathTool.cpp StewartBasic.cpp StewartFA.cpp Trajctory.cpp
  group GNU
    ./GNU/cminpack-1.3.8/: chkder.c chkder_.c covar.c covar_.c covar1.c dogleg.c dogleg_.c dpmpar.c dpmpar_.c enorm.c enorm_.c fdjac1.c fdjac1_.c fdjac2.c fdjac2_.c hybrd.c hybrd_.c hybrd1.c hybrd1_.c hybrj.c hybrj_.c hybrj1.c hybrj1_.c lmder.c lmder_.c lmder1.c lmder1_.c lmdif.c lmdif_.c lmdif1.c lmdif1_.c lmpar.c lmpar_.c lmstr.c lmstr_.c lmstr1.c lmstr1_.c qform.c qform_.c qrfac.c qrfac_.c qrsolv.c qrsolv_.c r1mpyq.c r1mpyq_.c r1updt.c r1updt_.c rwupdt.c rwupdt_.c
  group SYS
    ../Common/SYS/: FIFO.h FIFO.c
target Release (6160000::V6.16::ARMCLANG)
  device: STM32H755ZITx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: as above
  output: CortexM7
  c flags: Optim=5 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG,UNUSE_FULL_ASSERT,STM32H755xx,CORE_CM7
  c include: .\APP;..\Common;..\Common\BSP;..\Common\SYS;.\GNU\cminpack-1.3.8
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev, CMSIS:RTOS2:Keil RTX5 5.5.3, Compiler:Event Recorder 1.5.0, Compiler:I/O:STDOUT 1.2.0, Device:STM32Cube HAL:Common 1.9.0, Device:STM32Cube HAL:Cortex 1.9.0, Device:STM32Cube HAL:DMA 1.9.0, Device:STM32Cube HAL:GPIO 1.9.0, Device:STM32Cube HAL:HSEM 1.9.0, Device:STM32Cube HAL:PWR 1.9.0, Device:STM32Cube HAL:RCC 1.9.0, Device:STM32Cube HAL:SPI 1.9.0, Device:Startup 1.9.0
