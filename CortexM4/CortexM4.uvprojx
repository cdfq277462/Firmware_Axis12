# Keil uVision project CortexM4.uvprojx, settings and files
target Debug (6160000::V6.16::ARMCLANG)
  device: STM32H755ZITx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x10040000,0x00008000) IRAM2(0x10000000,0x00030000) IROM(0x08100000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CortexM4
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG,USE_FULL_ASSERT,CORE_CM4
  c include: .\APP;..\Common;..\Common\BSP;..\Common\SYS;..\Common\STM
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30040000 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x48000
  group APP
    ./APP/: main.h main.c task.h task.c sock.h sock.c test.h test.c idle.h idle.c
  group BSP
    ../Common/BSP/: BSP_STM32H7.h BSP_STM32H7.c IRQ_STM32H7.h IRQ_STM32H7.c MSP_STM32H7.h MSP_STM32H7.c LED_STM32H7.h LED_STM32H7.c ETH_STM32H7.h ETH_STM32H7.c COM_STM32H7.h COM_STM32H7.c ADC_STM32H7.h ADC_STM32H7.c EEP_STM32H7.h EEP_STM32H7.c
  group SYS
    ../Common/SYS/: FIFO.h FIFO.c CRC.h CRC.c MODBUS.h MODBUS.c
  group STM
    ../Common/STM/: eeprom.h eeprom.c
target Release (6160000::V6.16::ARMCLANG)
  device: STM32H755ZITx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: as above
  output: CortexM4
  c flags: Optim=5 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: NDEBUG,UNUSE_FULL_ASSERT,STM32H755xx,CORE_CM4
  c include: .\APP;..\Common;..\Common\BSP;..\Common\SYS;..\Common\STM
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30040000 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x48000
software components: CMSIS Driver:Ethernet MAC:Custom 1.0.0, CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, Compiler:Event Recorder 1.5.0, Compiler:I/O:STDOUT 1.2.0, Network:CORE 7.16.0, Network:Interface:ETH 7.16.0, Network:Socket:TCP 7.16.0, Network:Socket:UDP 7.16.0, CMSIS Driver:Ethernet PHY:LAN8742A 1.3.0, Device:STM32Cube HAL:ADC 1.9.0, Device:STM32Cube HAL:Common 1.9.0, Device:STM32Cube HAL:Cortex 1.9.0, Device:STM32Cube HAL:DMA 1.9.0, Device:STM32Cube HAL:ETH 1.9.0, Device:STM32Cube HAL:Flash 1.9.0, Device:STM32Cube HAL:GPIO 1.9.0, Device:STM32Cube HAL:HSEM 1.9.0, Device:STM32Cube HAL:PWR 1.9.0, Device:STM32Cube HAL:RCC 1.9.0, Device:STM32Cube HAL:TIM 1.9.0, Device:STM32Cube HAL:UART 1.9.0, Device:Startup 1.9.0
